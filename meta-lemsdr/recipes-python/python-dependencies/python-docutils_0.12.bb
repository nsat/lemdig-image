DESCRIPTION = "docutils"
LICENSE = "GPLv3"
LIC_FILES_CHKSUM = "file://licenses/gpl-3-0.txt;md5=d32239bcb673463ab874e80d47fae504"
SRC_URI[md5sum] = "4622263b62c5c771c03502afa3157768"
SRC_URI[sha256sum] = "c7db717810ab6965f66c8cf0398a98c9d8df982da39b4cd7f162911eb89596fa"

inherit pypi setuptools
