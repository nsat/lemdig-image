require recipes-core/images/lemsdr-image-packages.inc
