# LEMSDR layer over lmsensors-config recipe
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
