FILESEXTRAPATHS_prepend := "${THISDIR}/te0803-zynqmp:"

COMPATIBLE_MACHINE_te0803-zynqmp = "te0803-zynqmp"

SRC_URI += "file://psu_init_gpl.c"
