INITSCRIPT_PARAMS_avahi-daemon = "stop 20 0 1 6 ."
