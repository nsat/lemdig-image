# LEMDIG layer over Python 2.7.14 recipe
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}_${PV}:"
