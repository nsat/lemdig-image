IMAGE_INSTALL_append = " libstdc++-staticdev"
