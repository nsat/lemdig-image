DESCRIPTION = "virtualenv"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=51910050bd6ad04a50033f3e15d6ce43"
SRC_URI[md5sum] = "28d76a0d9cbd5dc42046dd14e76a6ecc"
SRC_URI[sha256sum] = "1a74278b8adb383ce4c7619e33c753b1eb7b58dc1e449601c096ca4b76125f84"

inherit pypi setuptools
